# Keil uVision project framework.uvprojx, settings and files
target framework (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: framework
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,USE_STM324x9I_EVAL,USE_USB_OTG_FS,USE_ULPI_PHY
  c include: ..\hardware\app\inc;..\hardware\main\inc;..\hardware\mcu\core\inc;..\hardware\mcu\driver\inc;..\hardware\mcu\usb\inc;..\hardware\module\inc;..\hardware\utils\inc;..\hardware\system\include;..\hardware\system\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../hardware/app/src/: app.c
  group main
    ../hardware/main/src/: main.c module.c utils.c
  group module
    ../hardware/module/src/: adc.c buzzer.c can.c cpu.c flash.c hmi.c io.c key.c led.c mpu.c power.c pwm.c rocker.c usb.c wifi.c
  group mcu
    ../hardware/mcu/core/src/: stm32f4xx_it.c system_stm32f4xx.c
    ../hardware/mcu/: keil_startup.s
  group mcu_driver
    ../hardware/mcu/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group mcu_usb
    ../hardware/mcu/usb/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group system
    ../hardware/system/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../hardware/system/portable/RVDS/ARM_CM4F/: port.c
    ../hardware/system/portable/MemMang/: heap_4.c
  group utils
    ../hardware/utils/src/: cjson.c delay.c
